# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HAVE_CONFIG_H
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\HARDWARE\WM8978;..\HARDWARE\IIC;..\APP;..\APP\wav;..\HARDWARE\I2S;..\MALLOC;..\HARDWARE\KEY;..\HARDWARE\SDIO;..\HARDWARE\W25QXX;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\SX1262;..\SPEEX\include\speex;..\SPEEX\libspeex;..\SPEEX;..\SPEEX\include;..\FreeRTOS\CMSIS_RTOS;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\LORA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../SPEEX/libspeex/: filterbank.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../README/: README.txt
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/WM8978/: wm8978.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/I2S/: i2s.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
  group APP
    ../APP/: recorder.c
  group MALLOC
    ../MALLOC/: malloc.c MemQueue.c
  group FRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group FRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group SPEEX
    ../SPEEX/libspeex/: bits.c cb_search.c exc_5_64_table.c exc_5_256_table.c exc_8_128_table.c exc_10_16_table.c exc_10_32_table.c exc_20_32_table.c filters.c gain_table.c gain_table_lbr.c hexc_10_32_table.c hexc_table.c high_lsp_tables.c kiss_fft.c kiss_fftr.c lpc.c lsp.c lsp_tables_nb.c ltp.c modes.c nb_celp.c quant_lsp.c sb_celp.c smallft.c speex.c speex_callbacks.c speex_header.c stereo.c testenc.c vbr.c vorbis_psy.c vq.c window.c preprocess.c mdf.c fftwrap.c
  group LORA
    ../LORA/: lora.c radio.c sx126x.c sx126x_hal.c
